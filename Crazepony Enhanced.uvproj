# Keil uVision project Crazepony Enhanced.uvproj, settings and files
target Crazepony (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103T8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Crazepony +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver;.\Control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group HardwareDriver
    ./HardWareDriver/: delay.c Led.c MPU6050.c Motors.c NRF24L01.c SPI.c stmflash.c UART1.c Battery.c MS5611.c
    ./HardwareDriver/: I2C.c Init_Config.c Interrupt_Config.c NRF24.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c IMU.c Altitude.c filter.c ConfigTable.c IMUSO3.c imu.h FailSafe.c FailSafe.h ConfigParams.h GlobalVariables.h GlobalVariables.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_adc.c
    ./User_Src/: stm32f10x_conf.h
  group Control
    ./Control/: Control.c ReceiveData.c
